DESCRIPTION = "U-Boot für STM32MP mit Falcon Mode"
LICENSE = "GPLv2"
# TODO: Auf neuen Branch wechseln
SRC_URI = "git://github.com/Superior404/u-boot.git;branch=v2023.10-stm32mp"

# Weitere Rezeptanpassungen ...

